# IAR project Qt_host_code.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2560 ATmega2560
  ICCAVR.newCCIncludePaths: ..\; ..\device_specific\QT1060; ..\device_specific\QT1070; ..\device_specific\QT2120; ..\device_specific\QT2160; ..\device_specific\QT60160; ..\device_specific\QT60240; ..\device_specific; ..\drivers/twi_driver; ..\utilities
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: configuration.h main.c
    ../utilities/: LED.c LED.h
    ../device_specific/QT1060/: QT1060.h
    ../device_specific/QT1070/: QT1070.h
    ../device_specific/QT1121/: QT1121.h
    ../device_specific/QT2120/: QT2120.h
    ../device_specific/QT2160/: QT2160.h
    ../device_specific/QT60160/: QT60160.h
    ../device_specific/QT60240/: QT60240.h
    ../device_specific/: QT_API.h QT_I2C.c
    ../drivers/TWI_driver/: TWI_Master.c TWI_Master.h
